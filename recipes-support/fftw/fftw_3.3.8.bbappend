# fftw static libraries are required by wsjtx

EXTRA_OECONF_append = " --enable-static --enable-fortran "
